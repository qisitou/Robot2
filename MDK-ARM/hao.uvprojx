# Keil uVision project hao.uvprojx, settings and files
target hao (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hao
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\HADRWARE;..\FWLIB\inc;..\FWLIB\src;..\USER;..\HARDWARE\LED;..\SYSTEM\usart1;..\SYSTEM\usart2;..\SYSTEM\usart3;..\SYSTEM\uart4;..\SYSTEM\uart5;..\SYSTEM\usart6;..\HARDWARE\CX522;..\HARDWARE\DMA;..\HARDWARE\BEEP;..\SYSTEM\CAN;..\HARDWARE\IM948;..\HARDWARE\CONTROL;..\HARDWARE\Emm_V5;..\SYSTEM\TIMER;..\HARDWARE\VL53L0X;..\HARDWARE\WS2812;..\HARDWARE\KEY;..\HARDWARE\DelayTask;..\HARDWARE\PwmServo;..\HARDWARE\LobotDigitalServoController;..\HARDWARE\Gray;..\HARDWARE\TASK;..\HARDWARE\PID;..\HARDWARE\StepMotor;..\HARDWARE\Infrared;..\HARDWARE\Turnplate;..\HARDWARE\Filter;..\HARDWARE\Openmv;..\HARDWARE\K230
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c stm32f4xx_it.c system_stm32f4xx.c LTCK.c LTCK.h headfile.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/CX522/: cx522.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/IM948/: im948_CMD.c
    ../HARDWARE/CONTROL/: control.c movement.c Chassis.c Chassis.h Chassis_Path.c Chassis_Path.h Chassis_PID.c Chassis_PID.h
    ../HARDWARE/Emm_V5/: Emm_V5.c
    ../HARDWARE/VL53L0X/: vl53l0x.c vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_i2c.c vl53l0x_it.c vl53l0x_platform.c
    ../HARDWARE/WS2812/: ws2812.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DelayTask/: DelayTask.c
    ../HARDWARE/PwmServo/: PwmServo.c
    ../HARDWARE/LobotDigitalServoController/: LobotDigitalServoController.c
    ../HARDWARE/Gray/: gray.c
    ../HARDWARE/TASK/: task.c task.h
    ../HARDWARE/PID/: PID.c PID.h
    ../HARDWARE/StepMotor/: StepMotor.h StepMotor.c
    ../HARDWARE/Infrared/: Infrared.c
    ../HARDWARE/Turnplate/: turnplate.c
    ../HARDWARE/Filter/: filter.c
    ../HARDWARE/Openmv/: openmv.c openmv.h
    ../HARDWARE/K230/: k230.c k230.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart1/: usart1.c
    ../SYSTEM/usart2/: usart2.c
    ../SYSTEM/usart3/: usart3.c
    ../SYSTEM/uart4/: uart4.c
    ../SYSTEM/uart5/: uart5.c
    ../SYSTEM/usart6/: usart6.c
    ../SYSTEM/CAN/: can.c
    ../SYSTEM/TIMER/: timer.c
software components: CMSIS:CORE 6.1.1
